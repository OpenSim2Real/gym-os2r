Commit message: fixed type in urdf

File: gym_os2r/models/models/monopod-fixed_hip/monopod-fixed_hip.urdf (robot description, URDF)
Before this commit: robot monopod-fixed_hip, 6 links, 5 joints
Joints:
- joint hip_joint: type continous -> continuous
