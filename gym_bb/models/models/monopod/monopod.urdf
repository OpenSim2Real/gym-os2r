Commit message: fixed the boom link inertia

File: gym_bb/models/models/monopod/monopod.urdf (robot description, URDF)
Before this commit: robot monopod, 6 links, 5 joints
Links:
- link boom_link: mass 0.12458 -> 0.414
